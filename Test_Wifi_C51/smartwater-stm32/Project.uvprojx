# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\Library;.\User;.\System;.\System\delay;.\System\usart;.\System\sys;.\Net\cJSON;.\Net\device;.\Net\MQTT;.\Net\onenet;.\Hardware\BEEP;.\Hardware\KEY;.\Hardware\LED;.\Hardware\Pump;.\Hardware\water;.\Hardware\waterflow;.\System\adc;.\System\EXTI;.\System\TIMER;.\Hardware\csb;.\Hardware\water_out;.\Shop\SP2_RC522\RC522;.\Shop\SP2_RC522\SPI;.\Shop\Pay;.\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/delay/: delay.c
    ./System/sys/: sys.c
    ./System/usart/: usart.c
    ./System/adc/: adc.c
    ./System/EXTI/: exti.c
    ./System/TIMER/: timer.c
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Hardware
    ./Hardware/BEEP/: beep.c
    ./Hardware/KEY/: key.c
    ./Hardware/LED/: led.c
    ./Hardware/Pump/: pump.c
    ./Hardware/water/: water.c
    ./Hardware/waterflow/: waterflow.c
    ./Hardware/csb/: Ultrasonic.c
    ./Hardware/water_out/: water_out.c
    ./Hardware/: ds18b20.c
  group shop
    ./Shop/SP2_RC522/RC522/: rc522.c
    ./Shop/SP2_RC522/SPI/: spi.c
    ./Shop/Pay/: pay.c
  group Net
    ./Net/cJSON/: cJSON.c
    ./Net/device/: esp8266.c
    ./Net/MQTT/: MqttKit.c
    ./Net/onenet/: onenet.c
