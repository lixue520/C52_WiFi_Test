# Keil uVision project Aliyun_C51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Aliyun_C51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\system;.\show
  group src
    ./src/: main.c
  group wifi
    ./wifi/: esp8266.c
  group system
    ./system/: usart.c delay.c
  group show
    ./show/: Lcd.c
